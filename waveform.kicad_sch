File: waveform.kicad_sch (KiCad schematic)
At the start: 12 parts

Commit message: Separate IO from main board
Parts:
- gave numbers to parts that had none: 12
